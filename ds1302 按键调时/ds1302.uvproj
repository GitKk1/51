# Keil uVision project ds1302.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: ds1302 +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51 main.c Delay.c Delay.h LCD1602.c LCD1602.h Timer0.c Timer0.h ds1302.c ds1302.h Key.c Key.h
